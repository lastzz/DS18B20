# Keil uVision project gui函数.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gui函数 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\delay;..\GUI;..\USER;..\ds18b20;..\tft;..\at24c04
  group Source Group 1
    ./: STARTUP.A51
  group delay
    ../delay/: delay.c
  group tft
    ../tft/: tft.C
  group GUI
    ../GUI/: GUI.C
  group main
    ./: Text3.c
  group ds18b20
    ../ds18b20/: ds18b20.c
  group AT24C04
    ../at24c04/: at24c04.c
